File: BPS_Test/Hardware/BPS_Test_Display.sch (KiCad schematic (older format))
At the start: 47 parts

Commit message: Cleaned up Schematics
Parts:
- gave numbers to parts that had none: 47
